SUMMARY = "A console-only image that fully supports the target device \
hardware."

IMAGE_INSTALL = "\
    dnsmasq"

LICENSE = "MIT"

inherit core-image
